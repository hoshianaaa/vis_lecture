Commit message: success

File: urdf/simple_body1.urdf (robot description, URDF)
Before this commit: robot test_robot, 2 links, 1 joints
Joints:
- joint body_joint: limit lower=-1.57 upper=1.57 effort=0.5 velocity=6.1 -> lower=-1.5 upper=1.5 effort=1000.0 velocity=0.5
